# Repository issaimaru/PowerSupply_v1 (continued)

## EAGLE design src/Azusa.brd (continued)

Parts:
B1: CS11029.5F100
B2: PTS645SM95SMTR92LFS
BOOTMODE: PINHD-1X2; 1X02
C18, C19, C20, C21, C22, C26, C31, C32, C33, C34, C35, C36: GCM188L81H104KA57
C23: GRM21BC72A105KE01
C24: GRM31CR71H475KA12
C27, C28: GRM0335C1E240GA01D
C29, C30: GRM0335C1H150FA01D; GRM0335C1H120GA01
FB1: BLM18KG121TN1D
JP2, JP3, JP4, JP5: 05-JST; B5B-XH
JP11: PINHD-1X6; 1X06
LED5, LED6, LED7, LED15: SML-E12V8WT86
ML1: 3220-14-0100-00
R11, R15, R29, R30, R31, R41: 100k; CR0603
R16, R17, R25, R26, R27, R28, R51, R52, R53: 0; CR0603
R42, R43, R44, R90: 100; CR0603
R45, R46, R48, R49: 10k; CR0603
R47, R50: 1k; CR0603
SB7: RSX101VAM-30TR
SW2: RDS-16S-1055-SMT-TR
SW3: SSSS213202
U1: LQFP64; STM32F446XC
U22: TC7S14F
X2: RH100-24.000-18-1020-EXT-TR
X3: 32.768K12.5PI/MC306

Connections:
+3V3: B2.1, BOOTMODE.2, C18.P$1, C19.P$1, C20.P$1, C21.P$1, FB1.1, JP11.1, ML1.3, SW2.C1 (C), SW2.C2 (C), SW3.2A (C), SW3.2B (C), U1.P1, U1.P19, U1.P32, U1.P48, U1.P64, U22.VCC; also elsewhere on the board
+5V: C31.P$1, C32.P$1, C33.P$1, C34.P$1, JP2.4, JP3.4, JP4.4, JP5.4; also elsewhere on the board
ALIVE_LED: R42.RIGHT, U1.P45
BOOT0: BOOTMODE.1, R11.LEFT, U1.P60
COM_LED: R43.RIGHT, U1.P44; also elsewhere on the board
CS: U1.P33; also elsewhere on the board
CURRENT1: U1.P8; also elsewhere on the board
CURRENT2: U1.P9; also elsewhere on the board
CURRENT3: U1.P10; also elsewhere on the board
CURRENT4: U1.P11; also elsewhere on the board
DEBUG_BT: R47.RIGHT, U1.P56
DEBUG_LED: R44.RIGHT, U1.P43
DEBUG_SW: R50.RIGHT, U1.P57
DIP_SW1: R41.RIGHT, SW2.1, U1.P54
DIP_SW2: R31.RIGHT, SW2.2, U1.P53
DIP_SW3: R25.RIGHT, R30.RIGHT, SW2.4, U1.P52
DIP_SW4: R26.RIGHT, R29.RIGHT, SW2.8, U1.P51
DIR1: U1.P24; also elsewhere on the board
DIR2: U1.P25; also elsewhere on the board
DIR3: U1.P26; also elsewhere on the board
DIR4: U1.P27; also elsewhere on the board
DISABLE: R90.RIGHT, U1.P20, U22.IN (I)
ENC1_A: JP2.3, U1.P41
ENC1_B: JP2.5, U1.P42
ENC2_A: JP4.3, U1.P22
ENC2_B: JP4.5, U1.P23
ENC3_A: JP3.3, U1.P58
ENC3_B: JP3.5, U1.P59
ENC4_A: JP5.3, U1.P37
ENC4_B: JP5.5, U1.P38
MISO: U1.P35; also elsewhere on the board
MOSI: U1.P36; also elsewhere on the board
unnamed: R16.LEFT, U1.P16
unnamed: R17.LEFT, U1.P17
unnamed: C22.P$1, C23.P$1, FB1.2, U1.P13
unnamed: C24.1, U1.P30
unnamed: C27.2, U1.P5, X2.1
unnamed: R28.RIGHT, U1.P4
unnamed: R27.RIGHT, U1.P6
unnamed: C28.2, R27.LEFT, X2.3 (2)
unnamed: C30.2, R28.LEFT, X3.1
unnamed: C29.2, U1.P3, X3.4 (2)
unnamed: LED5.A, R42.LEFT
unnamed: LED6.A, R43.LEFT
unnamed: LED7.A, R44.LEFT
unnamed: B2.4, R45.LEFT
unnamed: B2.3, R46.LEFT
unnamed: R48.LEFT, R49.LEFT, SW3.3A (R), SW3.3B (R)
unnamed: ML1.13, R51.LEFT
unnamed: C36.P$1, R48.RIGHT, R50.LEFT
unnamed: ML1.14, R52.RIGHT
unnamed: ML1.10, R53.RIGHT
unnamed: C35.P$1, R46.RIGHT, R47.LEFT
unnamed: SB7.A, U22.OUT (O)
unnamed: LED15.A, R90.LEFT
NRST: B1.1, C26.P$1, JP11.5, ML1.12, U1.P7
PWM1: R53.LEFT, U1.P50; also elsewhere on the board
PWM2: U1.P15; also elsewhere on the board
PWM3: U1.P29; also elsewhere on the board
PWM4: R15.RIGHT, U1.P28; also elsewhere on the board
SCK: U1.P34; also elsewhere on the board
SGND: B1.3, C18.P$2, C19.P$2, C20.P$2, C21.P$2, C22.P$2, C23.P$2, C24.2, C26.P$2, C27.1, C28.1, C29.1, C30.1, C31.P$2, C32.P$2, C33.P$2, C34.P$2, C35.P$2, C36.P$2, JP2.1, JP3.1, JP4.1, JP5.1, JP11.3, LED5.K (C), LED6.K (C), LED7.K (C), LED15.K (C), ML1.5, ML1.7, ML1.11, R11.RIGHT, R15.LEFT, R29.LEFT, R30.LEFT, R31.LEFT, R41.LEFT, R45.RIGHT, R49.RIGHT, U1.P12, U1.P18, U1.P31, U1.P47, U1.P63, U22.GND, X2.2 (SHIELD), X2.4 (SHIELD); also elsewhere on the board
SHUTDOWN: SB7.C; also elsewhere on the board
SWCLK: JP11.2, ML1.6, U1.P49
SWDIO: JP11.4, ML1.4, U1.P46
SWO: JP11.6, ML1.8, U1.P55
THERMAL: U1.P21; also elsewhere on the board
USART_RX: R17.RIGHT, R25.LEFT, R51.RIGHT; also elsewhere on the board
USART_TX: R16.RIGHT, R26.LEFT, R52.LEFT; also elsewhere on the board

Notes on the sheet:
BOOT0=0 - Boot from main flash memory
Boot
BOOT0=1 - Boot from system memory(boot loader)
Reset
Debug SW
Mode Select
STLINK-V3SET
Pilot Lamp
Bypass Capacitor
MCU
Encoder
DIP SW
STLINK CN

Parts:
C13, C14, C15: GCM188L81H104KA57
C16, C17: GRM0335C1H6R0BA01D; GRM0335C1H120GA01
JP7: PINHD-1X2; 1X02
R7: 120Ω; CR0603
R13, R34, R35, R36: 150; CR0603
R14: 0; CR0603
R37, R38: 10k; CR0603
R39, R40: 5.1k; CR0603
RJ45_1, RJ45_2: MTJ-88ARX1-LH
SW1: SS-12SDP2
TR1, TR2: 2SC3325
U2: MCP2517FD
U$1: MCP2558FD
X1: XRCGB40M000F4M01R0; XRCGB40M000F4M00R0

Connections:
+3V3: C13.P$2, C15.P$1, U2.VDD, U$1.VIO; also elsewhere on the board
+5V: C14.P$1, R13.RIGHT, R34.RIGHT, R35.LEFT, R36.LEFT, RJ45_1.1, RJ45_1.7, RJ45_2.1, RJ45_2.7, U$1.VDD; also elsewhere on the board
CAN_H: R7.RIGHT, RJ45_1.5, RJ45_1.6, RJ45_2.5, RJ45_2.6, U$1.CANH
CAN_L: RJ45_1.3, RJ45_1.4, RJ45_2.3, RJ45_2.4, SW1.C, U$1.CANL
COM_LED: R39.RIGHT, R40.RIGHT; also elsewhere on the board
CS: U2.NCS; also elsewhere on the board
MISO: U2.SDO; also elsewhere on the board
MOSI: U2.SDI; also elsewhere on the board
unnamed: R7.LEFT, SW1.R
unnamed: U2.TXCAN, U$1.TXD
unnamed: U2.RXCAN, U$1.RXD
unnamed: R14.LEFT, U2.OSC2
unnamed: C17.1, U2.OSC1, X1.1
unnamed: C16.1, R14.RIGHT, X1.2
unnamed: R13.LEFT, RJ45_1.LED2_A
unnamed: R34.LEFT, RJ45_2.LED2_A
unnamed: JP7.2, U$1.S
unnamed: R35.RIGHT, RJ45_1.LED1_A
unnamed: R36.RIGHT, RJ45_2.LED1_A
unnamed: RJ45_1.LED1_K, TR1.C
unnamed: RJ45_2.LED1_K, TR2.C
unnamed: R38.RIGHT, R40.LEFT, TR2.B
unnamed: R37.RIGHT, R39.LEFT, TR1.B
SCK: U2.SCK; also elsewhere on the board
SGND: C13.P$1, C14.P$2, C15.P$2, C16.2, C17.2, JP7.1, R37.LEFT, R38.LEFT, RJ45_1.2, RJ45_1.8, RJ45_1.LED2_K, RJ45_2.2, RJ45_2.8, RJ45_2.LED2_K, TR1.E, TR2.E, U2.VSS, U$1.EP (VSS), U$1.VSS; also elsewhere on the board

Notes on the sheet:
S=GND->normal mode S=VIN->silent mode
RJ45(CH1)
RJ45(CH2)
CAN BUS

Board: 4 copper layers, 105.0 x 137.0 mm, 315 parts (187 on the bottom side), 207 nets.

Other parts of the board:
HEATSINK1: V2020B

## EAGLE design src/PowerUnit-Bseries(ver1.0).brd

Parts:
C1: 50ZLH1000MEFC16X25
C2: GCM188L81H104KA57
CTRL1, CTRL2: 02-JST; B2B-XH
EDGE1, EDGE2, EDGE3, EDGE4: EDGE20X2
EDGE5: 7-5530843-6
H1, H2, H3, H4: MOUNT-HOLE3.2; 3,2
IN+: PADS14; AWG14
IN-: PADS14; AWG14
IRLB-1, IRLB-2: IRLB3813_2; TO-220AB-PUT
JP1: PINHD-1X2; 1X02
LED1, LED2, LED3: LED5MM
OUT1+, OUT1-, OUT2+, OUT2-, OUT3+, OUT3-, OUT4+, OUT4-: PADS14; AWG14
P-1, P-2, P-3, P-4, P-5, P-6, P-7, P-8: P-SWITCH
R1: 100; 0204/7
R2, R5: 680; 0204/7
R3: 1kΩ; 0204/7
R4: 10kΩ; 0204/7
SV1: ML10
SWITCH: 02-JST; B2B-XH
THRU1: 02-JST; B2B-XH
THRU+: PADS14; AWG14
THRU-: PADS14; AWG14
TLP1: 2227MC-08-03

Connections:
DIR1: EDGE1.P$21, EDGE5.P$12 (P12), SV1.9
DIR2: EDGE2.P$21, EDGE5.P$11 (P11), SV1.7
DIR3: EDGE3.P$21, EDGE5.P$10 (P10), SV1.5
DIR4: EDGE4.P$21, EDGE5.P$9 (P9), SV1.3
GND: C1.C (CATHODE), C2.P$2, IN-.P$1, IRLB-1.S, IRLB-2.S, JP1.1, LED1.K (C), R4.2, THRU-.P$1, TLP1.P$5 (GND)
GND2: EDGE1.P$19, EDGE2.P$19, EDGE3.P$19, EDGE4.P$19, EDGE5.P$8 (P8), LED2.K (C), SV1.1
LED: EDGE5.P$6 (P6), R1.1
unnamed: EDGE1.P$5, EDGE1.P$6, EDGE1.P$7, EDGE1.P$8, EDGE1.P$33, EDGE1.P$34, EDGE1.P$35, EDGE1.P$36, OUT1-.P$1
unnamed: EDGE2.P$5, EDGE2.P$6, EDGE2.P$7, EDGE2.P$8, EDGE2.P$33, EDGE2.P$34, EDGE2.P$35, EDGE2.P$36, OUT2-.P$1
unnamed: LED3.A, R5.1
unnamed: EDGE1.P$14, EDGE1.P$15, EDGE1.P$16, EDGE1.P$17, EDGE1.P$18, EDGE1.P$23, EDGE1.P$24, EDGE1.P$25, EDGE1.P$26, EDGE1.P$27, P-1.P$1, P-2.P$1
unnamed: EDGE2.P$1, EDGE2.P$2, EDGE2.P$3, EDGE2.P$4, EDGE2.P$37, EDGE2.P$38, EDGE2.P$39, EDGE2.P$40, OUT2+.P$1
unnamed: EDGE4.P$5, EDGE4.P$6, EDGE4.P$7, EDGE4.P$8, EDGE4.P$33, EDGE4.P$34, EDGE4.P$35, EDGE4.P$36, OUT4-.P$1
unnamed: EDGE3.P$5, EDGE3.P$6, EDGE3.P$7, EDGE3.P$8, EDGE3.P$33, EDGE3.P$34, EDGE3.P$35, EDGE3.P$36, OUT3-.P$1
unnamed: EDGE4.P$1, EDGE4.P$2, EDGE4.P$3, EDGE4.P$4, EDGE4.P$37, EDGE4.P$38, EDGE4.P$39, EDGE4.P$40, OUT4+.P$1
unnamed: EDGE3.P$14, EDGE3.P$15, EDGE3.P$16, EDGE3.P$17, EDGE3.P$18, EDGE3.P$23, EDGE3.P$24, EDGE3.P$25, EDGE3.P$26, EDGE3.P$27, P-5.P$1, P-6.P$1
unnamed: EDGE4.P$14, EDGE4.P$15, EDGE4.P$16, EDGE4.P$17, EDGE4.P$18, EDGE4.P$23, EDGE4.P$24, EDGE4.P$25, EDGE4.P$26, EDGE4.P$27, P-7.P$1, P-8.P$1
unnamed: LED1.A, R2.1
unnamed: LED2.A, R1.2
unnamed: CTRL1.2, CTRL2.2, SWITCH.1, THRU1.2, TLP1.P$2 (ANODE)
unnamed: R3.1, TLP1.P$6 (VOUT)
unnamed: CTRL1.1, CTRL2.1, JP1.2, THRU1.1, TLP1.P$3 (CATHODE)
unnamed: IRLB-1.G, IRLB-2.G, R3.2, R4.1
unnamed: IRLB-1.P$1 (PD), P-1.P$2, P-2.P$2, P-3.P$2, P-4.P$2
unnamed: IRLB-1.D, LED3.K (C)
unnamed: IRLB-2.P$1 (PD), P-5.P$2, P-6.P$2, P-7.P$2, P-8.P$2
unnamed: EDGE1.P$1, EDGE1.P$2, EDGE1.P$3, EDGE1.P$4, EDGE1.P$37, EDGE1.P$38, EDGE1.P$39, EDGE1.P$40, OUT1+.P$1
unnamed: EDGE2.P$14, EDGE2.P$15, EDGE2.P$16, EDGE2.P$17, EDGE2.P$18, EDGE2.P$23, EDGE2.P$24, EDGE2.P$25, EDGE2.P$26, EDGE2.P$27, P-3.P$1, P-4.P$1
unnamed: EDGE3.P$1, EDGE3.P$2, EDGE3.P$3, EDGE3.P$4, EDGE3.P$37, EDGE3.P$38, EDGE3.P$39, EDGE3.P$40, OUT3+.P$1
NC: EDGE5.P$7 (P7)
PWM1: EDGE1.P$20, EDGE5.P$1 (P1), SV1.10
PWM2: EDGE2.P$20, EDGE5.P$2 (P2), SV1.8
PWM3: EDGE3.P$20, EDGE5.P$3 (P3), SV1.6
PWM4: EDGE4.P$20, EDGE5.P$4 (P4), SV1.4
VCC: C1.A (ANODE), C2.P$1, EDGE1.P$9, EDGE1.P$10, EDGE1.P$11, EDGE1.P$12, EDGE1.P$13, EDGE1.P$28, EDGE1.P$29, EDGE1.P$30, EDGE1.P$31, EDGE1.P$32, EDGE2.P$9, EDGE2.P$10, EDGE2.P$11, EDGE2.P$12, EDGE2.P$13, EDGE2.P$28, EDGE2.P$29, EDGE2.P$30, EDGE2.P$31, EDGE2.P$32, EDGE3.P$9, EDGE3.P$10, EDGE3.P$11, EDGE3.P$12, EDGE3.P$13, EDGE3.P$28, EDGE3.P$29, EDGE3.P$30, EDGE3.P$31, EDGE3.P$32, EDGE4.P$9, EDGE4.P$10, EDGE4.P$11, EDGE4.P$12, EDGE4.P$13, EDGE4.P$28, EDGE4.P$29, EDGE4.P$30, EDGE4.P$31, EDGE4.P$32, IN+.P$1, R2.2, R5.2, SWITCH.2, THRU+.P$1, TLP1.P$8 (VCC)
VCC2: EDGE1.P$22, EDGE2.P$22, EDGE3.P$22, EDGE4.P$22, EDGE5.P$5 (P5), SV1.2

Notes on the sheet:
e2011220_竹内一晴
新電源基板(仮)_回路図
とりあえず適当設計(部品、後から選定する)
各エッジコネクタ38ピン目をNCにすると遠野と互換性があるのでそうした
logic input
MDC input
MDC LED check
BATT input
control
output
部品選定完了☑

Board: 2 copper layers, 112.7 x 77.0 mm, 48 parts (11 on the bottom side), 35 nets.

## Commit log

2022-05-14 Create LICENSE
2022-06-18 部品の配置
2022-06-18 配線の追加
2022-06-19 ベタの追加
2022-06-21 DRCエラーの解消
2022-06-21 配線完了
2022-06-21 Update README.md
    完成予想図の追加
2022-06-21 配線完了,KiCadへの移行の前段階
2022-06-21 Update .gitignore
    KiCAD用テンプレ
2022-06-21 KiCADへの移行
2022-06-22 QRコードの拡大
2022-06-22 KiCadへの移行前 ネジ穴の追加
2022-06-22 KiCadへの移行前 ネジ穴の追加 conflictの解消
2022-06-22 KiCadへの移行 QRコードの追加
2022-06-22 .gitignoreの反映されない問題の修復
2022-06-22 Update README.md
    画像の更新
2022-06-23 .gitignoreの更新
2022-06-23 エラーの解消
2022-06-23 基板デザインの完成
2022-06-24 Update README.md
    説明の追加
2022-06-25 Update README.md
    使用電子部品，及び値段の表の追加
2022-06-25 名前の変更、ガーバ,ドリルデータの追加
2022-06-25 gerberの名前の変更
2022-06-25 再設計 Edgeコネクタを40Pにした
2022-06-25 基盤デザインの完成 gerber出力
2022-06-26 基「板」デザインの完成 gerber出力
2022-06-26 前バージョンへの移行
2022-07-06 デザインの修正
2022-07-14 [add]readmeの更新
2022-08-06 Update LICENSE
2022-09-28 markdownの更新
2022-09-28 markdownの更新2
2022-12-21 XT60PWコネクタに変えた
2022-12-22 トランシーバ選定途中、XT60PW
2022-12-23 CANトランシーバの選定(クリスマスイブですよ？（笑）)
2022-12-25 CAN周りの配線など
2022-12-26 レギュレータの追加など
2022-12-27 5Vレギュレータの追加など
2022-12-28 理想ダイオード回路(ディスクリート)の追加
2022-12-29 5VDCDCのMLCC選定、電源回りの整理
2022-12-30 5VDCDCの出力コンをOSコンにした
2022-12-30 +5V周りの冗長性を高める回路を構成(大晦日ですよ？（笑）)
2023-01-05 CANコントローラのXtal選定
2023-01-05 トランシーバ部分の設計終わり(仮)
2023-01-06 STM32の電源回り
2023-01-08 OSC周り
2023-01-09 DIPスイッチ周り
2023-01-14 RJ45の追加
2023-01-15 電流センサ周りの回路
2023-02-10 電源制御系周り
2023-02-11 ヒューズ選定
2023-02-14 kairozunoseiri
2023-02-17 DGND未選別のところまで
2023-02-19 develop_v2
2023-03-07 2023/03/07 信号ラインの配線途中
2023-03-08 2023/03/08 sintyoku
2023-03-09 2023/03/09進捗分
2023-03-10 2023/03/10の進捗
2023-03-20 2023/03/20の進捗
2023-03-21 2023/03/21の進捗
2023-03-23 2023/03/23 配線終了
2023-03-23 DRC OK,before I move it KiCad.
2023-03-23 Kicadへの移行後
2023-03-24 3dmodel top
2023-03-25 シルク 裏面 2023/03/25進捗分
2023-03-26 2023/03/26途中(1)
2023-03-26 3Dモデル当て終了
2023-03-26 DRC完了
2023-03-27 2023/03/27 sintyoku
2023-03-30 JLCPCBロゴを追加
2023-03-30 基板微修正、JLCPCBロゴ追加
2023-04-05 微修正失敗(1.524mm)
2023-04-07 kansei 2
2023-05-13 rename-file
2023-05-23 [add]BOM
2023-05-23 [update]readme_BOM
2023-05-23 [update]readme.md
2023-05-23 LICENSE の更新
2023-05-30 [update
